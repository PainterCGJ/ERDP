# Keil uVision project mdk_gd32.uvprojx, settings and files
target GD32 (6220000::V6.22::ARMCLANG)
  device: GD32F470VK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0300000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mdk_gd32 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: GD32F470
  c include: ..\..\Source;..\..\Source\Application;..\..\Source\Kernel\Driver\CMSIS\GD\GD32F4xx\Include;..\..\Source\Kernel\Driver\CMSIS;..\..\Source\Kernel\Driver\GD32F4xx_standard_peripheral\Include;..\..\Source\Kernel\RTOS\FreeRTOS;..\..\Source\Kernel\RTOS\FreeRTOS\inc;..\..\Source\Kernel\RTOS\FreeRTOS\port\GCC\ARM_CM4F;..\..\Source\Interface;..\..\Source\Interface\Hardware\inc;..\..\Source\Interface\RTOS;..\..\Source\HAL;..\..\Source\HAL\GPIO;..\..\Source\HAL\UART;..\..\Source\HAL\SPI;..\..\Source\OSAL;..\..\Source\Library;..\..\Source\Library\printf;..\..\Source\Common
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../../Source/Application/: gd32f4xx_it.c main.cpp systick.c
  group Library
    ../../Source/Library/printf/: printf.c
  group HAL
    ../../Source/HAL/GPIO/: erdp_hal_gpio.cpp erdp_hal_gpio.hpp
    ../../Source/HAL/UART/: erdp_hal_uart.cpp erdp_hal_uart.hpp
    ../../Source/HAL/SPI/: erdp_hal_spi.cpp erdp_hal_spi.hpp
  group OSAL
    ../../Source/OSAL/: erdp_osal.cpp erdp_osal.hpp
  group Interface
    ../../Source/Interface/Hardware/src/: erdp_if_gpio.c erdp_if_uart.c erdp_if_spi.c erdp_if_interrupt.c
    ../../Source/Interface/RTOS/: erdp_if_rtos.c
  group Driver
    ../../Source/Kernel/Driver/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
    ../../Source/Kernel/Driver/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
    ../../Source/Kernel/Driver/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group RTOS
    ../../Source/Kernel/RTOS/FreeRTOS/port/MemMang/: heap_4.c
    ../../Source/Kernel/RTOS/FreeRTOS/port/GCC/ARM_CM4F/: port.c
    ../../Source/Kernel/RTOS/FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../Source/Kernel/RTOS/FreeRTOS/: FreeRTOSConfig.h
