# Keil uVision project erdp_gd32f470_freertos.uvprojx, settings and files
target GD32F470_FREERTOS (6220000::V6.22::ARMCLANG)
  device: GD32F470ZI GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x0B0000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gd32f4_freertos +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: GD32F470
  c misc: -fexceptions
  c include: ..\Source\Kernel\Drivers\GD32F4XX;..\Source\Kernel\Drivers\GD32F4XX\GD32F4xx_standard_peripheral\Include;..\Source\Kernel\Drivers\GD32F4XX\CMSIS;..\Source\Kernel\Drivers\GD32F4XX\CMSIS\GD\GD32F4xx\Include;..\Source\Kernel\RTOS\FreeRTOS;..\Source\Kernel\RTOS\FreeRTOS\inc;..\Source\Kernel\RTOS\FreeRTOS\port\GCC\ARM_CM4F;..\Source\Interface;..\Source\Interface\Drivers;..\Source\Interface\RTOS;..\Source\HAL;..\Source\HAL\EXTI;..\Source\HAL\GPIO;..\Source\HAL\SPI;..\Source\HAL\UART;..\Source\Common;..\Source\Service\Log;..\Source\Application;..\Source\OSAL;..\Source\Board
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xb0000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../Source/Application/: main.cpp
  group Common
    ../Source/Common/: erdp_config.h thread_config.h syscalls.c
  group Service
    ../Source/Service/Log/: log_service.cpp log_service.hpp
  group HAL
    ../Source/HAL/EXTI/: erdp_hal_exti.cpp erdp_hal_exti.hpp
    ../Source/HAL/GPIO/: erdp_hal_gpio.cpp erdp_hal_gpio.hpp
    ../Source/HAL/SPI/: erdp_hal_spi.cpp erdp_hal_spi.hpp
    ../Source/HAL/UART/: erdp_hal_uart.cpp erdp_hal_uart.hpp
  group OSAL
    ../Source/OSAL/: erdp_heap.cpp erdp_heap.hpp erdp_osal.cpp erdp_osal.hpp erdp_osal_event.cpp erdp_osal_event.hpp erdp_osal_fifo.hpp erdp_osal_queue.hpp erdp_osal_ringbuffer.hpp erdp_osal_semaphore.hpp erdp_osal_timer.cpp erdp_osal_timer.hpp
  group Interface/Driver
    ../Source/Interface/Drivers/GD32F4XX/: erdp_if_exti.c erdp_if_gpio.c erdp_if_spi.c erdp_if_sys.c erdp_if_uart.c
  group Interface/RTOS
    ../Source/Interface/RTOS/FreeRTOS/: erdp_if_rtos.c
  group Kernel/Driver
    ../Source/Kernel/Drivers/GD32F4XX/: gd32f4xx_it.c systick.c
    ../Source/Kernel/Drivers/GD32F4XX/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
    ../Source/Kernel/Drivers/GD32F4XX/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../Source/Kernel/Drivers/GD32F4XX/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group Kernel/RTOS
    ../Source/Kernel/RTOS/FreeRTOS/: FreeRTOSConfig.h
    ../Source/Kernel/RTOS/FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Source/Kernel/RTOS/FreeRTOS/port/MemMang/: heap_4.c
    ../Source/Kernel/RTOS/FreeRTOS/port/GCC/ARM_CM4F/: port.c
